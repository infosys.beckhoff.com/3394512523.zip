TYPE E_AnalysisIDs :
(
	(* analysis chain *)
	eID_Source := 1,
	eID_IntRMS,
	eID_Sink
) UDINT;
END_TYPE
