(* ISO Classes *)
{attribute 'qualified_only'}
TYPE E_IsoClass :
(
	A := 1,
	B,
	C,
	D
) UDINT;
END_TYPE
